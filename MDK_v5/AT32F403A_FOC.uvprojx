# Keil uVision project AT32F403A_FOC.uvprojx, settings and files
target AT32F403A_FOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F403ACCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GE2433_WSYS_2026_4_24 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ACCT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1_0
  c include: ..\AT32_Board;..\MDK_v5;..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\USER;..\Libraries\CMSIS\CM4\CoreSupport;..\Libraries\CMSIS\CM4\DeviceSupport;..\MotorCode;..\USER;..\UserCode;..\YouShua
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group UserCode
    ../UserCode/: interrupt.c mcuart.c mcflash.c
    ../MotorCode/: mclib.c
  group WuShua
    ../UserCode/: calculation.c mcctl.c logic.c protect.c fangbo_nohall.c fangbo.c
  group YouShua
    ../YouShua/: youshua.c YSmcctl.c YSlogic.c YSprotect.c YSstatemachine.c
  group User
    ../USER/: main.c gpio.c adc.c tim.c usart.c dac.c
  group Head
    ../UserCode/: userpara.h mcctl.h key.h calculation.h mcuart.h interrupt.h logic.h virtual_oscilloscope.h multi_button.h mcflash.h
    ../USER/: gpio.h adc.h at32f4xx_it.h tim.h usart.h
    ../MotorCode/: hallfoc.h mcekf.h mcfoc.h mclib.h
  group BSP
    ../AT32_Board/: at32_board.c PLLconfig.c
  group CMSIS
    ../USER/: at32f4xx_it.c system_at32f4xx.c
    ../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403acct7.s
  group AT32Periph
    ../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
